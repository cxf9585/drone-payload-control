## PX4/patches/payload_control_px4/Kconfig
```kconfig
menuconfig MODULES_PAYLOAD_CONTROL_PX4
	bool "payload_control_px4"
	default n
	---help---
		Build the UAV payload control command module.
```
